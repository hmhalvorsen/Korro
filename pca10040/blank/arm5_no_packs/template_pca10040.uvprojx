# Keil uVision project template_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0
  c include: ..\..\..\config\template_pca10040;..\..\..\config;D:\Nordic\SDK 12.2\components;D:\Nordic\SDK 12.2\components\boards;D:\Nordic\SDK 12.2\components\drivers_nrf\adc;D:\Nordic\SDK 12.2\components\drivers_nrf\clock;D:\Nordic\SDK 12.2\components\drivers_nrf\common;D:\Nordic\SDK 12.2\components\drivers_nrf\comp;D:\Nordic\SDK 12.2\components\drivers_nrf\delay;D:\Nordic\SDK 12.2\components\drivers_nrf\gpiote;D:\Nordic\SDK 12.2\components\drivers_nrf\hal;D:\Nordic\SDK 12.2\components\drivers_nrf\i2s;D:\Nordic\SDK 12.2\components\drivers_nrf\lpcomp;D:\Nordic\SDK 12.2\components\drivers_nrf\nrf_soc_nosd;D:\Nordic\SDK 12.2\components\drivers_nrf\pdm;D:\Nordic\SDK 12.2\components\drivers_nrf\power;D:\Nordic\SDK 12.2\components\drivers_nrf\ppi;D:\Nordic\SDK 12.2\components\drivers_nrf\pwm;D:\Nordic\SDK 12.2\components\drivers_nrf\qdec;D:\Nordic\SDK 12.2\components\drivers_nrf\rng;D:\Nordic\SDK 12.2\components\drivers_nrf\rtc;D:\Nordic\SDK 12.2\components\drivers_nrf\saadc;D:\Nordic\SDK 12.2\components\drivers_nrf\spi_master;D:\Nordic\SDK 12.2\components\drivers_nrf\spi_slave;D:\Nordic\SDK 12.2\components\drivers_nrf\swi;D:\Nordic\SDK 12.2\components\drivers_nrf\timer;D:\Nordic\SDK 12.2\components\drivers_nrf\twi_master;D:\Nordic\SDK 12.2\components\drivers_nrf\twis_slave;D:\Nordic\SDK 12.2\components\drivers_nrf\uart;D:\Nordic\SDK 12.2\components\drivers_nrf\wdt;D:\Nordic\SDK 12.2\components\libraries\bsp;D:\Nordic\SDK 12.2\components\libraries\button;D:\Nordic\SDK 12.2\components\libraries\crc16;D:\Nordic\SDK 12.2\components\libraries\crc32;D:\Nordic\SDK 12.2\components\libraries\csense;D:\Nordic\SDK 12.2\components\libraries\csense_drv;D:\Nordic\SDK 12.2\components\libraries\fifo;D:\Nordic\SDK 12.2\components\libraries\gpiote;D:\Nordic\SDK 12.2\components\libraries\hardfault;D:\Nordic\SDK 12.2\components\libraries\hardfault\nrf52;D:\Nordic\SDK 12.2\components\libraries\hci;D:\Nordic\SDK 12.2\components\libraries\led_softblink;D:\Nordic\SDK 12.2\components\libraries\log;D:\Nordic\SDK 12.2\components\libraries\log\src;D:\Nordic\SDK 12.2\components\libraries\low_power_pwm;D:\Nordic\SDK 12.2\components\libraries\mem_manager;D:\Nordic\SDK 12.2\components\libraries\pwm;D:\Nordic\SDK 12.2\components\libraries\queue;D:\Nordic\SDK 12.2\components\libraries\scheduler;D:\Nordic\SDK 12.2\components\libraries\slip;D:\Nordic\SDK 12.2\components\libraries\timer;D:\Nordic\SDK 12.2\components\libraries\twi;D:\Nordic\SDK 12.2\components\libraries\uart;D:\Nordic\SDK 12.2\components\libraries\util;D:\Nordic\SDK 12.2\components\toolchain;..\..\..;D:\Nordic\SDK 12.2\external\segger_rtt;..\config;..\..\..\components\src;..\..\..\components\include
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSWI_DISABLE0
  asm include: ..\..\..\config\template_pca10040;..\..\..\config;D:\Nordic\SDK 12.2\components;D:\Nordic\SDK 12.2\components\boards;D:\Nordic\SDK 12.2\components\drivers_nrf\adc;D:\Nordic\SDK 12.2\components\drivers_nrf\clock;D:\Nordic\SDK 12.2\components\drivers_nrf\common;D:\Nordic\SDK 12.2\components\drivers_nrf\comp;D:\Nordic\SDK 12.2\components\drivers_nrf\delay;D:\Nordic\SDK 12.2\components\drivers_nrf\gpiote;D:\Nordic\SDK 12.2\components\drivers_nrf\hal;D:\Nordic\SDK 12.2\components\drivers_nrf\i2s;D:\Nordic\SDK 12.2\components\drivers_nrf\lpcomp;D:\Nordic\SDK 12.2\components\drivers_nrf\nrf_soc_nosd;D:\Nordic\SDK 12.2\components\drivers_nrf\pdm;D:\Nordic\SDK 12.2\components\drivers_nrf\power;D:\Nordic\SDK 12.2\components\drivers_nrf\ppi;D:\Nordic\SDK 12.2\components\drivers_nrf\pwm;D:\Nordic\SDK 12.2\components\drivers_nrf\qdec;D:\Nordic\SDK 12.2\components\drivers_nrf\rng;D:\Nordic\SDK 12.2\components\drivers_nrf\rtc;D:\Nordic\SDK 12.2\components\drivers_nrf\saadc;D:\Nordic\SDK 12.2\components\drivers_nrf\spi_master;D:\Nordic\SDK 12.2\components\drivers_nrf\spi_slave;D:\Nordic\SDK 12.2\components\drivers_nrf\swi;D:\Nordic\SDK 12.2\components\drivers_nrf\timer;D:\Nordic\SDK 12.2\components\drivers_nrf\twi_master;D:\Nordic\SDK 12.2\components\drivers_nrf\twis_slave;D:\Nordic\SDK 12.2\components\drivers_nrf\uart;D:\Nordic\SDK 12.2\components\drivers_nrf\wdt;D:\Nordic\SDK 12.2\components\libraries\bsp;D:\Nordic\SDK 12.2\components\libraries\button;D:\Nordic\SDK 12.2\components\libraries\crc16;D:\Nordic\SDK 12.2\components\libraries\crc32;D:\Nordic\SDK 12.2\components\libraries\csense;D:\Nordic\SDK 12.2\components\libraries\csense_drv;D:\Nordic\SDK 12.2\components\libraries\fifo;D:\Nordic\SDK 12.2\components\libraries\gpiote;D:\Nordic\SDK 12.2\components\libraries\hardfault;D:\Nordic\SDK 12.2\components\libraries\hardfault\nrf52;D:\Nordic\SDK 12.2\components\libraries\hci;D:\Nordic\SDK 12.2\components\libraries\led_softblink;D:\Nordic\SDK 12.2\components\libraries\log;D:\Nordic\SDK 12.2\components\libraries\log\src;D:\Nordic\SDK 12.2\components\libraries\low_power_pwm;D:\Nordic\SDK 12.2\components\libraries\mem_manager;D:\Nordic\SDK 12.2\components\libraries\pwm;D:\Nordic\SDK 12.2\components\libraries\queue;D:\Nordic\SDK 12.2\components\libraries\scheduler;D:\Nordic\SDK 12.2\components\libraries\slip;D:\Nordic\SDK 12.2\components\libraries\timer;D:\Nordic\SDK 12.2\components\libraries\twi;D:\Nordic\SDK 12.2\components\libraries\uart;D:\Nordic\SDK 12.2\components\libraries\util;D:\Nordic\SDK 12.2\components\toolchain;..\..\..;D:\Nordic\SDK 12.2\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../components/src/: motor.c rc_pwm.c real_time_clock.c
  group Board Definition
    D:/Nordic/SDK 12.2/components/boards/: boards.c
  group Board Support
    D:/Nordic/SDK 12.2/components/libraries/bsp/: bsp.c bsp_nfc.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    D:/Nordic/SDK 12.2/components/drivers_nrf/hal/: nrf_adc.c nrf_saadc.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/adc/: nrf_drv_adc.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/clock/: nrf_drv_clock.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/common/: nrf_drv_common.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/comp/: nrf_drv_comp.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/i2s/: nrf_drv_i2s.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/lpcomp/: nrf_drv_lpcomp.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/pdm/: nrf_drv_pdm.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/power/: nrf_drv_power.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/qdec/: nrf_drv_qdec.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/rng/: nrf_drv_rng.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/rtc/: nrf_drv_rtc.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/swi/: nrf_drv_swi.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/timer/: nrf_drv_timer.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/twis_slave/: nrf_drv_twis.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/uart/: nrf_drv_uart.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/wdt/: nrf_drv_wdt.c
    D:/Nordic/SDK 12.2/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    D:/Nordic/SDK 12.2/components/libraries/button/: app_button.c
    D:/Nordic/SDK 12.2/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    D:/Nordic/SDK 12.2/components/libraries/fifo/: app_fifo.c
    D:/Nordic/SDK 12.2/components/libraries/gpiote/: app_gpiote.c
    D:/Nordic/SDK 12.2/components/libraries/pwm/: app_pwm.c
    D:/Nordic/SDK 12.2/components/libraries/scheduler/: app_scheduler.c
    D:/Nordic/SDK 12.2/components/libraries/timer/: app_timer.c
    D:/Nordic/SDK 12.2/components/libraries/twi/: app_twi.c
    D:/Nordic/SDK 12.2/components/libraries/uart/: app_uart_fifo.c
    D:/Nordic/SDK 12.2/components/libraries/crc16/: crc16.c
    D:/Nordic/SDK 12.2/components/libraries/crc32/: crc32.c
    D:/Nordic/SDK 12.2/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    D:/Nordic/SDK 12.2/components/libraries/hardfault/: hardfault_implementation.c
    D:/Nordic/SDK 12.2/components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
    D:/Nordic/SDK 12.2/components/libraries/led_softblink/: led_softblink.c
    D:/Nordic/SDK 12.2/components/libraries/low_power_pwm/: low_power_pwm.c
    D:/Nordic/SDK 12.2/components/libraries/mem_manager/: mem_manager.c
    D:/Nordic/SDK 12.2/components/libraries/csense/: nrf_csense.c
    D:/Nordic/SDK 12.2/components/libraries/csense_drv/: nrf_drv_csense.c
    D:/Nordic/SDK 12.2/components/libraries/queue/: nrf_queue.c
    D:/Nordic/SDK 12.2/components/libraries/slip/: slip.c
  group nRF_Log
    D:/Nordic/SDK 12.2/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    D:/Nordic/SDK 12.2/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
